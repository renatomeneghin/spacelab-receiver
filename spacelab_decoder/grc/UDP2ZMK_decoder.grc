options:
  parameters:
    generate_options: no_gui
    id: UDPtoZMQ
    output_language: python
    thread_safe_setters: '1'
    title: UDP to ZMQ Decoder
  states: {}

blocks:
- name: UDP_Port
  id: variable
  parameters:
    value: '2114'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: zmq_addr
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:2112"'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.25'
    gain_omega: '0.001'
    mu: '0'
    omega: samp_rate/(baudrate)
    omega_relative_limit: '0.001'
    type: float
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    port: UDP_Port
    src_zeros: 'False'
    type: float
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: zmq_addr
    timeout: '100'
    type: byte
  states: {}

connections:
- [digital_binary_slicer_fb_0, '0', zeromq_push_sink_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [network_udp_source_0, '0', digital_clock_recovery_mm_xx_0, '0']

metadata:
  file_format: 1
