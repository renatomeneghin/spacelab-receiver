options:
  parameters:
    generate_options: qt_gui
    id: Test1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: zmq_address
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:2112"'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '80'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.25'
    gain_omega: '0.001'
    mu: '0'
    omega: samp_rate/baudrate
    omega_relative_limit: '0.001'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e4
    win: window.WIN_HAMMING
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    gain0: '40'
    samp_rate: samp_rate
    sd_spec0: '"A:A"'
    sync: sync
    type: fc32
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: zmq_address
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', zeromq_push_sink_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
