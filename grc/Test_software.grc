options:
  parameters:
    author: renato
    generate_options: qt_gui
    id: Test_software
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: zmq_address
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:2112"'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.25'
    mu: '0'
    omega_relative_limit: '0.001'
    samples_per_symbol: int(samp_rate/baudrate)
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '1234'
    src_zeros: 'False'
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: zmq_address
    timeout: '100'
    type: byte
  states: {}

connections:
- [digital_gmsk_demod_0, '0', zeromq_push_sink_0, '0']
- [network_udp_source_0, '0', digital_gmsk_demod_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
